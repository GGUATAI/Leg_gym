# Keil uVision project VANGUARD_H7_X_RM_Leg.uvprojx, settings and files
target VANGUARD_H7_X_RM_Leg (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: VANGUARD_H7_X_RM_Leg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../Module/Motor/DM_Motor;../Module/IMU/BMI088;../BSP/CAN;../BSP/DWT;../BSP/PWM;../BSP/USART;../Algorithm/CRC;../Algorithm/EKF;../Algorithm/Filter;../Algorithm/Kalman;../Algorithm/Filter/Mahony;../Algorithm/PID;../Algorithm/VMC;../APP;../Module/VOFA;../Middlewares/ST/ARM/DSP/Lib;../Module/SBUS;../Module/WS2812;../BSP/SPI;../BSP/GPIO;../Algorithm/Basic_Function;../Algorithm/Controller;../Algorithm/Filter/LPF;../Module/GPS
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group BSP
    ../BSP/DWT/: bsp_dwt.c bsp_dwt.h
    ../BSP/CAN/: bsp_can.c bsp_can.h
    ../BSP/USART/: bsp_usart.c bsp_usart.h
    ../BSP/PWM/: bsp_PWM.c bsp_PWM.h
    ../BSP/GPIO/: bsp_gpio.c bsp_gpio.h
    ../BSP/SPI/: bsp_spi.c bsp_spi.h
  group Module
    ../Module/Motor/DM_Motor/: dm_motor.c dm_motor.h
    ../Module/IMU/BMI088/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h
    ../Module/VOFA/: vofa.c vofa.h
    ../Module/SBUS/: sbus.c sbus.h
    ../Module/WS2812/: ws2812.c ws2812.h
    ../Module/GPS/: GPRMC.c GPRMC.h
  group Algorithm
    ../Algorithm/CRC/: crc.c crc.h
    ../Algorithm/EKF/: QuaternionEKF.c QuaternionEKF.h
    ../Algorithm/Filter/LPF/: LPF.c LPF.h
    ../Algorithm/Kalman/: kalman_filter.c kalman_filter.h
    ../Algorithm/PID/: pid.c pid.h digital_pid.c digital_pid.h
    ../Algorithm/VMC/: VMC_Calc.c VMC_Calc.h
    ../Algorithm/Basic_Function/: user_lib.c user_lib.h
    ../Algorithm/Controller/: controller.c controller.h
    ../Algorithm/Filter/: filter.c filter.h
    ../Algorithm/Filter/Mahony/: mahony_filter.c mahony_filter.h
  group APP
    ../APP/: INS_Task.c INS_Task.h Remote_Control_Task.c Remote_Control_Task.h Chassis_L_Task.c Chassis_L_Task.h Chassis_Leg_Task.c Chassis_Leg_Task.h Chassis_R_Task.c Chassis_R_Task.h Observe_Task.c Observe_Task.h Robot_Init_Config.c Robot_Init_Config.h Message_Center_Task.c Message_Center_Task.h Gimbal_Task.c Gimbal_Task.h Frame_Config.h
  group DSP
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM7lfdp_math.lib
software components: CMSIS:CORE 4.3.0
